# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\app;..\bsp;..\Library;..\Source;..\Start;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM3;..\Hardware;..\User
  memory RVCT4: ROM 0x8005000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library
    ../Library/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c
    ../Start/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c core_cm3.c
  group BSP
    ../bsp/: GPIO.c delay.c MyI2C.c I2C.c
  group FreeRTOS
    ../FreeRTOS/src/: queue.c tasks.c list.c timers.c event_groups.c
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group Hardware
    ../Hardware/: OLED.c DHT11.c MPU6050.c AT24C02.c
  group User
    ../User/: main.c stm32f10x_it.c FreeRTOSConfig.h stm32f10x_conf.h APP.c

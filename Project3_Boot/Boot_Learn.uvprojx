# Keil uVision project Boot_Learn.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Boot_Learn +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\System;.\Start;.\Library;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c
  group Sys
    ./System/: delay.c usart.c I2C.c SPI.c boot.c
  group Hardware
    ./Hardware/: AT24C02.c FLASH.c W25Q64.c
  group User
    ./User/: main.c stm32f10x_it.c stm32f10x_conf.h
  group Library
    ./Library/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rcc.c
